# Repository sarahemm/cern-mimic-panel

File README.md:

# cern-mimic-panel
LED display showing the current status of the CERN accelerator complex

## KiCad design mini-lhc-display/hardware/mini-lhc-display.kicad_pcb

Parts:
C1, C9, C10: 10uF; C_0603_1608Metric
C2, C3, C4, C8, C13: 0.1uF; C_0603_1608Metric
C11, C12, C28, C29: 22uF; C_0603_1608Metric
C26, C27: 47pF; C_0603_1608Metric
CN1: Link In; Amphenol-RJLSE4018101
CN2: ICSP; Tag-Connect_TC2030-IDC-NL_2x03_P1.27mm_Vertical
L1, L2: 3.3uF; L_Cenker_CKCS8080
R1: 1k; R_0603_1608Metric
R2, R8, R10: 10k; R_0603_1608Metric
R9: 33.2k; R_0603_1608Metric
R11: 56.2k; R_0603_1608Metric
SW1: Reset; SW_SPST_PTS645
TP1: +3.3V; TestPoint_Pad_2.0x2.0mm
TP2: +5V; TestPoint_Pad_2.0x2.0mm
TP3: GND; TestPoint_Pad_3.0x3.0mm
TP4: LINK_I2C_SCL; TestPoint_Pad_2.0x2.0mm
TP5: LINK_I2C_SDA; TestPoint_Pad_2.0x2.0mm
TP6: LCD_BL_EN; TestPoint_Pad_2.0x2.0mm
TP7: LCD_~{RESET}; TestPoint_Pad_2.0x2.0mm
TP8: LCD_SCLK; TestPoint_Pad_2.0x2.0mm
TP9: LCD_DATA; TestPoint_Pad_2.0x2.0mm
TP10: LCD_~{CS}; TestPoint_Pad_2.0x2.0mm
TP11: LCD_A0; TestPoint_Pad_2.0x2.0mm
TP12: LED_MCU_SDI; TestPoint_Pad_2.0x2.0mm
TP13: LED_MCU_SDO; TestPoint_Pad_2.0x2.0mm
TP14: LED_LAT; TestPoint_Pad_2.0x2.0mm
TP15: LED_GSCLK; TestPoint_Pad_2.0x2.0mm
TP16: LED_SPI_SCLK; TestPoint_Pad_2.0x2.0mm
TP17: MTX_~{CE}_A; TestPoint_Pad_2.0x2.0mm
TP18: MTX_FLASH; TestPoint_Pad_2.0x2.0mm
TP19: MTX_~{RD}; TestPoint_Pad_2.0x2.0mm
TP20: MTX_~{RESET}; TestPoint_Pad_2.0x2.0mm
TP21: MTX_~{WR}; TestPoint_Pad_2.0x2.0mm
TP22: 7SEG_SCL; TestPoint_Pad_2.0x2.0mm
TP23: 7SEG_SDA; TestPoint_Pad_2.0x2.0mm
TP24: SPI_DATA_BEAM_MISC; TestPoint_Pad_2.0x2.0mm
TP25: +15V; TestPoint_Pad_2.0x2.0mm
U1: PIC32MX130F064D-IPT; TQFP-44_10x10mm_P0.8mm
U2, U6: AP62300TWU; TSOT-23-6

Connections:
+3.3V: C2.2, C3.2, C12.1, C27.2, C29.1, CN2.2 (VDD), L1.2, R2.2, R9.2, TP1.1, U1.17 (AVDD), U1.28 (VDD), U1.40 (VDD); also elsewhere on the board
+5V: C11.1, C26.2, C28.1, L2.2, R11.2, TP2.1; also elsewhere on the board
+15V: C9.1, C10.1, CN1.1, CN1.7, CN1.8, TP25.1, U2.3 (IN), U6.3 (IN); also elsewhere on the board
/7SEG_SCL: TP22.1, U1.44 (RB8); also elsewhere on the board
/7SEG_SDA: TP23.1, U1.1 (RB9); also elsewhere on the board
/Dot Matrix Displays/MTX_ADDR2: U1.12 (RA10); also elsewhere on the board
/Dot Matrix Displays/MTX_ADDR3: U1.35 (RA9); also elsewhere on the board
/Dot Matrix Displays/MTX_ADDR4: U1.32 (RA8); also elsewhere on the board
/Dot Matrix Displays/MTX_DATA0: U1.25 (RC0); also elsewhere on the board
/Dot Matrix Displays/MTX_DATA1: U1.26 (RC1); also elsewhere on the board
/Dot Matrix Displays/MTX_DATA2: U1.27 (RC2); also elsewhere on the board
/Dot Matrix Displays/MTX_DATA3: U1.36 (RC3); also elsewhere on the board
/Dot Matrix Displays/MTX_DATA4: U1.37 (RC4); also elsewhere on the board
/Dot Matrix Displays/MTX_DATA5: U1.38 (RC5); also elsewhere on the board
/Dot Matrix Displays/MTX_DATA6: U1.2 (RC6); also elsewhere on the board
/MTX_FLASH: TP18.1, U1.30 (RA2); also elsewhere on the board
/MTX_~CE_C: U1.19 (RA0); also elsewhere on the board
/MTX_~CE_D: U1.20 (RA1); also elsewhere on the board
/MTX_~RD: TP19.1, U1.31 (RA3); also elsewhere on the board
/MTX_~RESET: TP20.1, U1.34 (RA4); also elsewhere on the board
/MTX_~WR: TP21.1, U1.13 (RA7); also elsewhere on the board
/SPI_DATA_BEAM_MISC: TP24.1; also elsewhere on the board
GND: C1.1, C2.1, C3.1, C4.1, C9.2, C10.2, C11.2, C12.2, C28.2, C29.2, CN1.2, CN1.3, CN1.6, CN1.SH, CN2.3 (VSS), R8.1, R10.1, SW1.1, TP3.1, U1.6 (VSS), U1.16 (AVSS), U1.29 (VSS), U1.39 (VSS), U2.1 (GND), U6.1 (GND); also elsewhere on the board
LCD_A0: TP11.1, U1.3 (RC7); also elsewhere on the board
LCD_BL_EN: TP6.1, U1.33 (RB4); also elsewhere on the board
LCD_MCU_SDO: TP9.1, U1.4 (RC8); also elsewhere on the board
LCD_SPI_SCLK: TP8.1, U1.15 (RB15); also elsewhere on the board
LCD_~CS: TP10.1, U1.5 (RC9); also elsewhere on the board
LCD_~RESET: TP7.1, U1.8 (RB10); also elsewhere on the board
LED_GSCLK: TP15.1, U1.11 (RB13); also elsewhere on the board
LED_LAT: TP14.1, U1.43 (RB7); also elsewhere on the board
LED_MCU_SDI: TP12.1, U1.41 (RB5); also elsewhere on the board
LED_MCU_SDO: TP13.1, U1.42 (RB6); also elsewhere on the board
LED_SPI_SCLK: TP16.1, U1.14 (RB14); also elsewhere on the board
LINK_I2C_SCL: CN1.5, TP4.1, U1.24 (RB3)
LINK_I2C_SDA: CN1.4, TP5.1, U1.23 (RB2)
MTX_~CE_A: TP17.1, U1.10 (RB12); also elsewhere on the board
MTX_~CE_B: U1.9 (RB11); also elsewhere on the board
unnamed: C4.2, R1.2, R2.1
unnamed: C1.2, U1.7 (VCAP)
unnamed: C8.2, U2.6 (BST)
unnamed: C26.1, R10.2, R11.1, U2.4 (FB)
unnamed: C8.1, L2.1, U2.2 (SW)
unnamed: C13.2, U6.6 (BST)
unnamed: C27.1, R8.2, R9.1, U6.4 (FB)
unnamed: C13.1, L1.1, U6.2 (SW)
PGC: CN2.5 (PGC/ICSPCLK), U1.22 (RB1)
PGD: CN2.4 (PGD/ICSPDAT), U1.21 (RB0)
~MCLR: CN2.1 (~MCLR/VPP), R1.1, SW1.2, U1.18 (~MCLR)

Parts:
C14: 0.1uF; C_0603_1608Metric
DSP5: t(SP) Display; Fairchild-MSQC4XX1C
DSP6: Energy MS Digit; Broadcom-HDSM-281x_283x
DSP7: Energy Almost-MS Digit; Broadcom-HDSM-281x_283x
DSP8: Energy Almost-LS Digit; Broadcom-HDSM-281x_283x
DSP9: Energy LS Digit; Broadcom-HDSM-281x_283x
R3: 1k; R_0603_1608Metric
U7: AS1115-BSST; QSOP-24_3.9x8.7mm_P0.635mm

Connections:
+3.3V: C14.1, R3.1, U7.19 (VDD); also elsewhere on the board
/7 Segment Displays/A_DIG0: DSP5.1 (CA1), U7.2 (DIG0)
/7 Segment Displays/A_DIG1: DSP5.2 (CA2), DSP5.4 (CA_L1L2), U7.3 (DIG1)
/7 Segment Displays/A_DIG2: DSP5.6 (CA3), DSP5.10 (CA_L3), U7.4 (DIG2)
/7 Segment Displays/A_DIG3: DSP5.8 (CA4), U7.5 (DIG3)
/7 Segment Displays/A_DIG4: DSP9.4 (CA), DSP9.9 (CA), U7.7 (DIG4)
/7 Segment Displays/A_DIG5: DSP8.4 (CA), DSP8.9 (CA), U7.8 (DIG5)
/7 Segment Displays/A_DIG6: DSP7.4 (CA), DSP7.9 (CA), U7.9 (DIG6)
/7 Segment Displays/A_DIG7: DSP6.4 (CA), DSP6.9 (CA), U7.10 (DIG7)
/7 Segment Displays/C_SEGA: DSP5.14 (A), DSP6.5 (A), DSP7.5 (A), DSP8.5 (A), DSP9.5 (A), U7.15 (SEGA)
/7 Segment Displays/C_SEGB: DSP5.16 (B), DSP6.6 (B), DSP7.6 (B), DSP8.6 (B), DSP9.6 (B), U7.17 (SEGB)
/7 Segment Displays/C_SEGC: DSP5.13 (C), DSP6.8 (C), DSP7.8 (C), DSP8.8 (C), DSP9.8 (C), U7.20 (SEGC)
/7 Segment Displays/C_SEGD: DSP5.3 (D), DSP6.10 (D), DSP7.10 (D), DSP8.10 (D), DSP9.10 (D), U7.23 (SEGD)
/7 Segment Displays/C_SEGDP: DSP5.9 (L3), DSP5.12 (L1L2), DSP6.7 (DP2), DSP7.7 (DP2), DSP8.7 (DP2), DSP9.7 (DP2), U7.22 (SEGDP)
/7 Segment Displays/C_SEGE: DSP5.5 (E), DSP6.11 (E), DSP7.11 (E), DSP8.11 (E), DSP9.11 (E), U7.21 (SEGE)
/7 Segment Displays/C_SEGF: DSP5.11 (F), DSP6.3 (F), DSP7.3 (F), DSP8.3 (F), DSP9.3 (F), U7.16 (SEGF)
/7 Segment Displays/C_SEGG: DSP5.15 (G), DSP6.1 (G), DSP7.1 (G), DSP8.1 (G), DSP9.1 (G), U7.18 (SEGG)
/7SEG_SCL: U7.14 (SCL); also elsewhere on the board
/7SEG_SDA: U7.1 (SDA); also elsewhere on the board
GND: C14.2, U7.6 (GND); also elsewhere on the board
unnamed: R3.2, U7.13 (ISET)

Parts:
C5, C6, C7: 0.1uF; C_0603_1608Metric
DSP1: Accel Mode Left; Broadcom-QDSP-2536_2540
DSP2: Accel Mode Right; Broadcom-QDSP-2536_2540
DSP3: Beam Mode Left; Broadcom-QDSP-2536_2540
DSP4: Beam Mode Right; Broadcom-QDSP-2536_2540
U3, U4, U5: SN74LVC245APW; TSSOP-20_4.4x6.5mm_P0.65mm

Connections:
+3.3V: C5.1, C6.1, C7.1, U3.20 (VCC), U4.1 (DIR), U4.20 (VCC), U5.1 (DIR), U5.20 (VCC); also elsewhere on the board
+5V: DSP1.11 (CLS), DSP1.15 (VDD), DSP2.15 (VDD), DSP3.15 (VDD), DSP4.15 (VDD); also elsewhere on the board
/Dot Matrix Displays/A0: DSP1.3 (A0), DSP2.3 (A0), DSP3.3 (A0), DSP4.3 (A0), U5.14 (B5)
/Dot Matrix Displays/A1: DSP1.4 (A1), DSP2.4 (A1), DSP3.4 (A1), DSP4.4 (A1), U5.15 (B4)
/Dot Matrix Displays/A2: DSP1.5 (A2), DSP2.5 (A2), DSP3.5 (A2), DSP4.5 (A2), U5.16 (B3)
/Dot Matrix Displays/A3: DSP1.6 (A3), DSP2.6 (A3), DSP3.6 (A3), DSP4.6 (A3), U5.17 (B2)
/Dot Matrix Displays/A4: DSP1.10 (A4), DSP2.10 (A4), DSP3.10 (A4), DSP4.10 (A4), U5.18 (B1)
/Dot Matrix Displays/CLK: DSP1.12 (CLK), DSP2.12 (CLK), DSP3.12 (CLK), DSP4.12 (CLK)
/Dot Matrix Displays/D0: DSP1.20 (D0), DSP2.20 (D0), DSP3.20 (D0), DSP4.20 (D0), U3.18 (B1)
/Dot Matrix Displays/D1: DSP1.21 (D1), DSP2.21 (D1), DSP3.21 (D1), DSP4.21 (D1), U3.17 (B2)
/Dot Matrix Displays/D2: DSP1.25 (D2), DSP2.25 (D2), DSP3.25 (D2), DSP4.25 (D2), U3.16 (B3)
/Dot Matrix Displays/D3: DSP1.26 (D3), DSP2.26 (D3), DSP3.26 (D3), DSP4.26 (D3), U3.15 (B4)
/Dot Matrix Displays/D4: DSP1.27 (D4), DSP2.27 (D4), DSP3.27 (D4), DSP4.27 (D4), U3.14 (B5)
/Dot Matrix Displays/D5: DSP1.28 (D5), DSP2.28 (D5), DSP3.28 (D5), DSP4.28 (D5), U3.13 (B6)
/Dot Matrix Displays/D6: DSP1.29 (D6), DSP2.29 (D6), DSP3.29 (D6), DSP4.29 (D6), U3.12 (B7)
/Dot Matrix Displays/D7: DSP1.30 (D7), DSP2.30 (D7), DSP3.30 (D7), DSP4.30 (D7), U3.11 (B8)
/Dot Matrix Displays/FL: DSP1.2 (FL), DSP2.2 (FL), DSP3.2 (FL), DSP4.2 (FL), U4.16 (B3)
/Dot Matrix Displays/MTX_ADDR2: U5.4 (A3); also elsewhere on the board
/Dot Matrix Displays/MTX_ADDR3: U5.3 (A2); also elsewhere on the board
/Dot Matrix Displays/MTX_ADDR4: U5.2 (A1); also elsewhere on the board
/Dot Matrix Displays/MTX_DATA0: U3.2 (A1); also elsewhere on the board
/Dot Matrix Displays/MTX_DATA1: U3.3 (A2); also elsewhere on the board
/Dot Matrix Displays/MTX_DATA2: U3.4 (A3); also elsewhere on the board
/Dot Matrix Displays/MTX_DATA3: U3.5 (A4); also elsewhere on the board
/Dot Matrix Displays/MTX_DATA4: U3.6 (A5); also elsewhere on the board
/Dot Matrix Displays/MTX_DATA5: U3.7 (A6); also elsewhere on the board
/Dot Matrix Displays/MTX_DATA6: U3.8 (A7); also elsewhere on the board
/Dot Matrix Displays/~CE_AL: DSP1.14 (CE), U4.12 (B7)
/Dot Matrix Displays/~CE_AR: DSP2.14 (CE), U4.17 (B2)
/Dot Matrix Displays/~CE_BL: DSP3.14 (CE), U4.14 (B5)
/Dot Matrix Displays/~CE_BR: DSP4.14 (CE), U4.18 (B1)
/Dot Matrix Displays/~RD: DSP1.19 (RD), DSP2.19 (RD), DSP3.19 (RD), DSP4.19 (RD), U4.11 (B8)
/Dot Matrix Displays/~RST: DSP1.1 (RST), DSP2.1 (RST), DSP3.1 (RST), DSP4.1 (RST), U4.15 (B4)
/Dot Matrix Displays/~WR: DSP1.13 (WR), DSP2.13 (WR), DSP3.13 (WR), DSP4.13 (WR), U4.13 (B6)
/MTX_FLASH: U4.4 (A3); also elsewhere on the board
/MTX_~CE_C: U4.6 (A5); also elsewhere on the board
/MTX_~CE_D: U4.2 (A1); also elsewhere on the board
/MTX_~RD: U3.1 (DIR), U4.9 (A8); also elsewhere on the board
/MTX_~RESET: U4.5 (A4); also elsewhere on the board
/MTX_~WR: U4.7 (A6); also elsewhere on the board
GND: C5.2, C6.2, C7.2, DSP1.16 (GND), DSP1.18 (GND), DSP2.11 (CLS), DSP2.16 (GND), DSP2.18 (GND), DSP3.11 (CLS), DSP3.16 (GND), DSP3.18 (GND), DSP4.11 (CLS), DSP4.16 (GND), DSP4.18 (GND), U3.10 (GND), U3.19 (~OE), U4.10 (GND), U4.19 (~OE), U5.7 (A6), U5.8 (A7), U5.9 (A8), U5.10 (GND), U5.19 (~OE); also elsewhere on the board
LCD_A0: U3.9 (A8); also elsewhere on the board
LCD_MCU_SDO: U5.6 (A5); also elsewhere on the board
LCD_~CS: U5.5 (A4); also elsewhere on the board
MTX_~CE_A: U4.8 (A7); also elsewhere on the board
MTX_~CE_B: U4.3 (A2); also elsewhere on the board

Parts:
C15: 0.1uF; C_0603_1608Metric
LED1, LED2, LED3, LED4, LED5, LED6, LED7, LED8, LED9, LED10, LED11, LED12, LED13, LED14, LED15, LED16, LED17, LED18, LED19, LED20, LED21, LED22, LED23, LED24: Beam 1; LED_1206_3216Metric
LED25, LED26, LED27, LED28, LED29, LED30, LED31, LED32, LED33, LED34, LED35, LED36, LED37, LED38, LED39, LED40, LED41, LED42, LED43, LED44, LED45, LED46, LED47, LED48: Beam 2; LED_1206_3216Metric
U8: TLC5955DCA; HTSSOP-56-1EP_6.1x14mm_P0.5mm_EP3.61x6.35mm

Connections:
+3.3V: C15.1, U8.54 (VCC); also elsewhere on the board
+15V: LED1.2 (A), LED2.2 (A), LED3.2 (A), LED4.2 (A), LED5.2 (A), LED6.2 (A), LED7.2 (A), LED8.2 (A), LED9.2 (A), LED10.2 (A), LED11.2 (A), LED12.2 (A), LED13.2 (A), LED14.2 (A), LED15.2 (A), LED16.2 (A), LED17.2 (A), LED18.2 (A), LED19.2 (A), LED20.2 (A), LED21.2 (A), LED22.2 (A), LED23.2 (A), LED24.2 (A), LED25.2 (A), LED26.2 (A), LED27.2 (A), LED28.2 (A), LED29.2 (A), LED30.2 (A), LED31.2 (A), LED32.2 (A), LED33.2 (A), LED34.2 (A), LED35.2 (A), LED36.2 (A), LED37.2 (A), LED38.2 (A), LED39.2 (A), LED40.2 (A), LED41.2 (A), LED42.2 (A), LED43.2 (A), LED44.2 (A), LED45.2 (A), LED46.2 (A), LED47.2 (A), LED48.2 (A); also elsewhere on the board
/Beam LEDs/C0: LED27.1 (K), U8.8 (OUTR0)
/Beam LEDs/C1: LED26.1 (K), U8.9 (OUTG0)
/Beam LEDs/C2: LED4.1 (K), U8.7 (OUTB0)
/Beam LEDs/C3: LED32.1 (K), U8.14 (OUTR1)
/Beam LEDs/C4: LED8.1 (K), U8.15 (OUTG1)
/Beam LEDs/C5: LED7.1 (K), U8.13 (OUTB1)
/Beam LEDs/C6: LED9.1 (K), U8.17 (OUTR2)
/Beam LEDs/C7: LED34.1 (K), U8.18 (OUTG2)
/Beam LEDs/C8: LED33.1 (K), U8.16 (OUTB2)
/Beam LEDs/C9: LED13.1 (K), U8.23 (OUTR3)
/Beam LEDs/C10: LED37.1 (K), U8.24 (OUTG3)
/Beam LEDs/C11: LED38.1 (K), U8.22 (OUTB3)
/Beam LEDs/C12: LED5.1 (K), U8.5 (OUTR4)
/Beam LEDs/C13: LED28.1 (K), U8.6 (OUTG4)
/Beam LEDs/C14: LED29.1 (K), U8.4 (OUTB4)
/Beam LEDs/C15: LED6.1 (K), U8.11 (OUTR5)
/Beam LEDs/C16: LED31.1 (K), U8.12 (OUTG5)
/Beam LEDs/C17: LED30.1 (K), U8.10 (OUTB5)
/Beam LEDs/C18: LED11.1 (K), U8.20 (OUTR6)
/Beam LEDs/C19: LED14.1 (K), U8.21 (OUTG6)
/Beam LEDs/C20: LED10.1 (K), U8.19 (OUTB6)
/Beam LEDs/C21: LED12.1 (K), U8.26 (OUTR7)
/Beam LEDs/C22: LED35.1 (K), U8.27 (OUTG7)
/Beam LEDs/C23: LED36.1 (K), U8.25 (OUTB7)
/Beam LEDs/C24: LED3.1 (K), U8.52 (OUTR8)
/Beam LEDs/C25: LED2.1 (K), U8.51 (OUTG8)
/Beam LEDs/C26: LED25.1 (K), U8.53 (OUTB8)
/Beam LEDs/C27: LED47.1 (K), U8.46 (OUTR9)
/Beam LEDs/C28: LED22.1 (K), U8.45 (OUTG9)
/Beam LEDs/C29: LED23.1 (K), U8.47 (OUTB9)
/Beam LEDs/C30: LED18.1 (K), U8.37 (OUTR10)
/Beam LEDs/C31: LED42.1 (K), U8.36 (OUTG10)
/Beam LEDs/C32: LED43.1 (K), U8.38 (OUTB10)
/Beam LEDs/C33: LED39.1 (K), U8.31 (OUTR11)
/Beam LEDs/C34: LED15.1 (K), U8.30 (OUTG11)
/Beam LEDs/C35: LED40.1 (K), U8.32 (OUTB11)
/Beam LEDs/C36: LED24.1 (K), U8.49 (OUTR12)
/Beam LEDs/C37: LED48.1 (K), U8.48 (OUTG12)
/Beam LEDs/C38: LED1.1 (K), U8.50 (OUTB12)
/Beam LEDs/C39: LED21.1 (K), U8.43 (OUTR13)
/Beam LEDs/C40: LED45.1 (K), U8.42 (OUTG13)
/Beam LEDs/C41: LED46.1 (K), U8.44 (OUTB13)
/Beam LEDs/C42: LED44.1 (K), U8.40 (OUTR14)
/Beam LEDs/C43: LED19.1 (K), U8.39 (OUTG14)
/Beam LEDs/C44: LED20.1 (K), U8.41 (OUTB14)
/Beam LEDs/C45: LED41.1 (K), U8.34 (OUTR15)
/Beam LEDs/C46: LED16.1 (K), U8.33 (OUTG15)
/Beam LEDs/C47: LED17.1 (K), U8.35 (OUTB15)
/SPI_DATA_BEAM_MISC: U8.28 (SOUT); also elsewhere on the board
GND: C15.2, U8.29 (GND), U8.56 (GND), U8.57 (THRMPAD); also elsewhere on the board
LED_GSCLK: U8.55 (GSCLK); also elsewhere on the board
LED_LAT: U8.3 (LAT); also elsewhere on the board
LED_MCU_SDO: U8.1 (SIN); also elsewhere on the board
LED_SPI_SCLK: U8.2 (SCLK); also elsewhere on the board

Parts:
C16: 0.1uF; C_0603_1608Metric
LED49: Beam 1 Dump; LED_Inolux_IN-P55TATRGB_PLCC6_5.0x5.5mm_P1.8mm
LED50: Beam 2 Dump; LED_Inolux_IN-P55TATRGB_PLCC6_5.0x5.5mm_P1.8mm
LED51: IP 1; LED_Inolux_IN-P55TATRGB_PLCC6_5.0x5.5mm_P1.8mm
LED52: IP 2; LED_Inolux_IN-P55TATRGB_PLCC6_5.0x5.5mm_P1.8mm
LED53: IP 5; LED_Inolux_IN-P55TATRGB_PLCC6_5.0x5.5mm_P1.8mm
LED54: IP 8; LED_Inolux_IN-P55TATRGB_PLCC6_5.0x5.5mm_P1.8mm
LED55, LED56: Beam 1 Dump Tunnel; LED_1206_3216Metric
LED57, LED58, LED59: Beam 1 TI 2; LED_1206_3216Metric
LED60, LED61: Beam 2 Dump Tunnel; LED_1206_3216Metric
LED62, LED63, LED64: Beam 2 TI 8; LED_1206_3216Metric
LED65: B1 Beam Permit; R_Array_Convex_2x1206
LED66: B1 Stable Beams; R_Array_Convex_2x1206
LED67: B1 Movables Allowed In; R_Array_Convex_2x1206
LED68: Permit Link; R_Array_Convex_2x1206
LED69: B2 Beam Permit; R_Array_Convex_2x1206
LED70: B2 Stable Beams; R_Array_Convex_2x1206
LED71: B2 Movables Allowed In; R_Array_Convex_2x1206
LED72: Cryo Status; R_Array_Convex_2x1206
LED73: B1 Collimator Status; R_Array_Convex_2x1206
LED74: B2 Collimator Status; R_Array_Convex_2x1206
U9: TLC5955DCA; HTSSOP-56-1EP_6.1x14mm_P0.5mm_EP3.61x6.35mm

Connections:
+3.3V: C16.1, U9.54 (VCC); also elsewhere on the board
+15V: LED49.4 (AG), LED49.5 (AR), LED49.6 (AB), LED50.4 (AG), LED50.5 (AR), LED50.6 (AB), LED51.4 (AG), LED51.5 (AR), LED51.6 (AB), LED52.4 (AG), LED52.5 (AR), LED52.6 (AB), LED53.4 (AG), LED53.5 (AR), LED53.6 (AB), LED54.4 (AG), LED54.5 (AR), LED54.6 (AB), LED55.2 (A), LED56.2 (A), LED57.2 (A), LED58.2 (A), LED59.2 (A), LED60.2 (A), LED61.2 (A), LED62.2 (A), LED63.2 (A), LED64.2 (A), LED65.3 (A1), LED65.4 (A2), LED66.3 (A1), LED66.4 (A2), LED67.3 (A1), LED67.4 (A2), LED68.3 (A1), LED68.4 (A2), LED69.3 (A1), LED69.4 (A2), LED70.3 (A1), LED70.4 (A2), LED71.3 (A1), LED71.4 (A2), LED72.3 (A1), LED72.4 (A2), LED73.3 (A1), LED73.4 (A2), LED74.3 (A1), LED74.4 (A2); also elsewhere on the board
/Misc. LEDs/C18: LED55.1 (K), U9.20 (OUTR6)
/Misc. LEDs/C19: LED56.1 (K), U9.21 (OUTG6)
/Misc. LEDs/C20: LED61.1 (K), U9.19 (OUTB6)
/Misc. LEDs/C21: LED60.1 (K), U9.26 (OUTR7)
/Misc. LEDs/C22: LED62.1 (K), U9.27 (OUTG7)
/Misc. LEDs/C23: LED63.1 (K), U9.25 (OUTB7)
/Misc. LEDs/C24: LED59.1 (K), U9.52 (OUTR8)
/Misc. LEDs/C25: LED58.1 (K), U9.51 (OUTG8)
/Misc. LEDs/C26: LED64.1 (K), U9.53 (OUTB8)
/Misc. LEDs/C27: LED74.1 (K2), U9.46 (OUTR9)
/Misc. LEDs/C28: LED73.1 (K2), U9.45 (OUTG9)
/Misc. LEDs/C29: LED74.2 (K1), U9.47 (OUTB9)
/Misc. LEDs/C30: LED68.2 (K1), U9.37 (OUTR10)
/Misc. LEDs/C31: LED68.1 (K2), U9.36 (OUTG10)
/Misc. LEDs/C32: LED67.1 (K2), U9.38 (OUTB10)
/Misc. LEDs/C33: LED69.1 (K2), U9.31 (OUTR11)
/Misc. LEDs/C34: LED69.2 (K1), U9.30 (OUTG11)
/Misc. LEDs/C35: LED70.1 (K2), U9.32 (OUTB11)
/Misc. LEDs/C36: LED72.2 (K1), U9.49 (OUTR12)
/Misc. LEDs/C37: LED72.1 (K2), U9.48 (OUTG12)
/Misc. LEDs/C38: LED57.1 (K), U9.50 (OUTB12)
/Misc. LEDs/C39: LED65.2 (K1), U9.43 (OUTR13)
/Misc. LEDs/C40: LED65.1 (K2), U9.42 (OUTG13)
/Misc. LEDs/C41: LED73.2 (K1), U9.44 (OUTB13)
/Misc. LEDs/C42: LED66.1 (K2), U9.40 (OUTR14)
/Misc. LEDs/C43: LED67.2 (K1), U9.39 (OUTG14)
/Misc. LEDs/C44: LED66.2 (K1), U9.41 (OUTB14)
/Misc. LEDs/C45: LED71.1 (K2), U9.34 (OUTR15)
/Misc. LEDs/C46: LED70.2 (K1), U9.33 (OUTG15)
/Misc. LEDs/C47: LED71.2 (K1), U9.35 (OUTB15)
/Misc. LEDs/C_B0: LED51.1 (KB), U9.7 (OUTB0)
/Misc. LEDs/C_B1: LED50.1 (KB), U9.13 (OUTB1)
/Misc. LEDs/C_B2: LED53.1 (KB), U9.16 (OUTB2)
/Misc. LEDs/C_B3: LED49.1 (KB), U9.22 (OUTB3)
/Misc. LEDs/C_B4: LED52.1 (KB), U9.4 (OUTB4)
/Misc. LEDs/C_B5: LED54.1 (KB), U9.10 (OUTB5)
/Misc. LEDs/C_G0: LED51.2 (KR), U9.9 (OUTG0)
/Misc. LEDs/C_G1: LED50.2 (KR), U9.15 (OUTG1)
/Misc. LEDs/C_G2: LED53.2 (KR), U9.18 (OUTG2)
/Misc. LEDs/C_G3: LED49.2 (KR), U9.24 (OUTG3)
/Misc. LEDs/C_G4: LED52.2 (KR), U9.6 (OUTG4)
/Misc. LEDs/C_G5: LED54.2 (KR), U9.12 (OUTG5)
/Misc. LEDs/C_R0: LED51.3 (KG), U9.8 (OUTR0)
/Misc. LEDs/C_R1: LED50.3 (KG), U9.14 (OUTR1)
/Misc. LEDs/C_R2: LED53.3 (KG), U9.17 (OUTR2)
/Misc. LEDs/C_R3: LED49.3 (KG), U9.23 (OUTR3)
/Misc. LEDs/C_R4: LED52.3 (KG), U9.5 (OUTR4)
/Misc. LEDs/C_R5: LED54.3 (KG), U9.11 (OUTR5)
/SPI_DATA_BEAM_MISC: U9.1 (SIN); also elsewhere on the board
GND: C16.2, U9.29 (GND), U9.56 (GND), U9.57 (THRMPAD); also elsewhere on the board
LED_GSCLK: U9.55 (GSCLK); also elsewhere on the board
LED_LAT: U9.3 (LAT); also elsewhere on the board
LED_MCU_SDI: U9.28 (SOUT); also elsewhere on the board
LED_SPI_SCLK: U9.2 (SCLK); also elsewhere on the board

Notices in the files:
mini-lhc-display/firmware/mini-lhc-display/src/config/default/peripheral/gpio/plib_gpio.h:
Copyright (C) 2019 Microchip Technology Inc. and its subsidiaries.
cern-display-controller/hardware/cern-display-controller.kicad_pcb:
© 2025 sen CC-BY-SA
