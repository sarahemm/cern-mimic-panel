# Repository sarahemm/cern-mimic-panel (continued)

## KiCad design mini-lhc-display/hardware/mini-lhc-display.kicad_pcb (continued)

Parts:
C17, C18, C19, C20, C21, C22, C23, C24, C25: 1uF; C_0603_1608Metric
Q1: MMBT5551L; SOT-23
R4, R5, R6: 42.2; R_0603_1608Metric
R7: 5.1k; R_0603_1608Metric
U10: EA_DOGM128X-6; EA_DOGM128-6

Connections:
+3.3V: R4.1, R5.1, R6.1, U10.34 (VDD2), U10.35 (VDD); also elsewhere on the board
GND: C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, Q1.2 (E), U10.26 (VSS), U10.33 (VSS); also elsewhere on the board
LCD_A0: U10.38 (A0); also elsewhere on the board
LCD_BL_EN: R7.1; also elsewhere on the board
LCD_MCU_SDO: U10.36 (SI); also elsewhere on the board
LCD_SPI_SCLK: U10.37 (SCL); also elsewhere on the board
LCD_~CS: U10.40 (~CS1B); also elsewhere on the board
LCD_~RESET: U10.39 (~RST); also elsewhere on the board
unnamed: Q1.1 (B), R7.2
unnamed: Q1.3 (C), U10.18 (C1-), U10.19 (C2-), U10.20 (C3-)
unnamed: R4.2, U10.1 (A1+)
unnamed: R5.2, U10.2 (A2+)
unnamed: R6.2, U10.3 (A3+)
unnamed: C17.2, C18.2, U10.30 (CAP1N)
unnamed: C17.1, U10.29 (CAP1P)
unnamed: C25.2, U10.27 (CAP2N)
unnamed: C25.1, U10.28 (CAP2P)
unnamed: C18.1, U10.31 (CAP3P)
unnamed: C19.1, U10.21 (V0)
unnamed: C20.1, U10.22 (V1)
unnamed: C21.1, U10.23 (V2)
unnamed: C22.1, U10.24 (V3)
unnamed: C23.1, U10.25 (V4)
unnamed: C24.1, U10.32 (VOUT)

Board: 2 copper layers, 161.0 x 175.8 mm, 164 parts (80 on the bottom side), 200 nets.

## KiCad design cern-display-controller/hardware/cern-display-controller.kicad_pcb

Parts:
C1: 10uF; C_0603_1608Metric
C2, C5, C7: 0.1uF; C_0603_1608Metric
C3, C6: 22uF; C_0603_1608Metric
C8: 1uF; C_0603_1608Metric
F5: 1A Hold, 2A Trip; Fuse_2920_7451Metric
JP1: Disable Port 1; PinHeader_1x02_P2.54mm_Vertical
JP2: Disable Port 2; PinHeader_1x02_P2.54mm_Vertical
JP3: Disable Port 3; PinHeader_1x02_P2.54mm_Vertical
JP4: Disable Port 4; PinHeader_1x02_P2.54mm_Vertical
LED1: Power; LED_0603_1608Metric
LED2: Status; LED_0603_1608Metric
LED3: WiFi; LED_0603_1608Metric
R3, R4, R5: 402; R_0603_1608Metric
R6: 5.1k; R_0603_1608Metric
R7, R8: 10k; R_0603_1608Metric
RN1, RN2, RN3, RN4: 4.7k; R_Array_Convex_4x0603
SW2: Reset; SW_SPST_PTS645
SW3: Boot; SW_SPST_PTS645
U1: N7803-1PH; MeanWell-N78-H
U2: PCA9518; TSSOP-20_4.4x6.5mm_P0.65mm
U3: ESP32-C6-WROOM-1

Connections:
+3.3V: C3.1, C5.1, C6.2, C7.1, R3.1, R4.1, R5.1, R6.1, R7.1, R8.1, RN1.5 (R4.2), RN1.6 (R3.2), RN1.7 (R2.2), RN1.8 (R1.2), RN2.5 (R4.2), RN2.6 (R3.2), RN3.5 (R4.2), RN3.6 (R3.2), RN3.7 (R2.2), RN3.8 (R1.2), RN4.5 (R4.2), RN4.6 (R3.2), RN4.7 (R2.2), RN4.8 (R1.2), U1.3 (OUT), U2.20 (VCC), U3.2 (3V3); also elsewhere on the board
+15V: F5.2; also elsewhere on the board
/LINK1_EN: JP1.2 (B), U2.7 (EN1)
/LINK2_EN: JP2.2 (B), U2.11 (EN2)
/LINK3_EN: JP3.2 (B), U2.14 (EN3)
/LINK4_EN: JP4.2 (B), U2.17 (EN4)
BOOT0: R8.2, U3.10 (GPIO8)
BOOT1: R7.2, SW3.2, U3.15 (GPIO9)
BTN_DOWN: U3.18 (GPIO20); also elsewhere on the board
BTN_LEFT: U3.19 (GPIO21); also elsewhere on the board
BTN_RIGHT: U3.20 (GPIO22); also elsewhere on the board
BTN_SELECT: U3.21 (GPIO23); also elsewhere on the board
BTN_UP: U3.17 (GPIO19); also elsewhere on the board
ESP_~RESET: C8.2, R6.2, SW2.2, U3.3 (EN/CHIP_PU); also elsewhere on the board
EXPSCL1: RN1.4 (R4.1), U2.1 (EXPSCL1); also elsewhere on the board
EXPSCL2: RN3.1 (R1.1), U2.2 (EXPSCL2); also elsewhere on the board
EXPSDA1: RN1.3 (R3.1), U2.18 (EXPSDA1); also elsewhere on the board
EXPSDA2: RN3.4 (R4.1), U2.19 (EXPSDA2); also elsewhere on the board
GND: C1.2, C2.2, C3.2, C5.2, C6.1, C7.2, C8.1, JP1.1 (A), JP2.1 (A), JP3.1 (A), JP4.1 (A), LED1.1 (K), SW2.1, SW3.1, U1.2 (GND), U2.10 (GND), U3.1 (GND), U3.28 (GND), U3.29 (GND); also elsewhere on the board
JTAG_TCK: U3.6 (MTCK/GPIO6/ADC1_CH6); also elsewhere on the board
JTAG_TDI: U3.5 (MTDI/GPIO5/ADC1_CH5); also elsewhere on the board
JTAG_TDO: U3.7 (MTDO/GPIO7); also elsewhere on the board
JTAG_TMS: U3.4 (MTMS/GPIO4/ADC1_CH4); also elsewhere on the board
LCD_MISO: U3.23 (GPIO15); also elsewhere on the board
LCD_MOSI: U3.16 (GPIO18); also elsewhere on the board
LCD_SCLK: U3.8 (GPIO0/ADC1_CH0/XTAL_32K_P); also elsewhere on the board
LCD_~RESET: U3.9 (GPIO1/ADC1_CH1/XTAL_32K_N); also elsewhere on the board
LED_STATUS: LED2.1 (K), U3.27 (GPIO2/ADC1_CH2)
LED_WIFI: LED3.1 (K), U3.26 (GPIO3/ADC1_CH3)
LINK1_SCL: RN2.4 (R4.1), U2.5 (SCL1); also elsewhere on the board
LINK1_SDA: RN2.3 (R3.1), U2.6 (SDA1); also elsewhere on the board
LINK2_SCL: RN3.2 (R2.1), U2.8 (SCL2); also elsewhere on the board
LINK2_SDA: RN3.3 (R3.1), U2.9 (SDA2); also elsewhere on the board
LINK3_SCL: RN4.4 (R4.1), U2.12 (SCL3); also elsewhere on the board
LINK3_SDA: RN4.3 (R3.1), U2.13 (SDA3); also elsewhere on the board
LINK4_SCL: RN4.2 (R2.1), U2.15 (SCL4); also elsewhere on the board
LINK4_SDA: RN4.1 (R1.1), U2.16 (SDA4); also elsewhere on the board
MCU_SCL: RN1.2 (R2.1), U2.3 (SCL0), U3.11 (GPIO10); also elsewhere on the board
MCU_SDA: RN1.1 (R1.1), U2.4 (SDA0), U3.12 (GPIO11); also elsewhere on the board
unnamed: LED1.2 (A), R3.2
unnamed: LED2.2 (A), R4.2
unnamed: LED3.2 (A), R5.2
unnamed: C1.1, C2.1, F5.1, U1.1 (IN)
UART_RX_I: U3.24 (U0RXD/GPIO17); also elsewhere on the board
UART_TX_O: U3.25 (U0TXD/GPIO16); also elsewhere on the board
USB_D+: U3.14 (GPIO13/USB_D+); also elsewhere on the board
USB_D-: U3.13 (GPIO12/USB_D-); also elsewhere on the board

Parts:
C9, C10, C11, C12, C13, C14, C15: 1uF; C_0603_1608Metric
C16: 0.1uF; C_0603_1608Metric
CN1: Power In (15V); BarrelJack_Horizontal
CN2: Link Port 1; RJ45_Amphenol_RJHSE5380
CN3: Link Port 2; RJ45_Amphenol_RJHSE5380
CN4: Link Port 3; RJ45_Amphenol_RJHSE5380
CN5: Link Port 4; RJ45_Amphenol_RJHSE5380
CN6: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_G-Switch_GT-USB-7010ASV
CN7: Serial; PinHeader_1x06_P2.54mm_Vertical; not fitted
CN8: JTAG; PinHeader_2x10_P2.54mm_Vertical; not fitted
CN9: Expansion; PinHeader_2x07_P2.54mm_Vertical; not fitted
DSP1: EA_DOGM204-A; EA-DOGM204-A
F1, F2, F3, F4: 1A Hold, 2A Trip; Fuse_2920_7451Metric
Rx-1, Rx-2: R_0603_1608Metric; not fitted
SW1: Power; E_Switch-ANR11-H
SW4: Navigation; E_Switch-JS1300
TP1: GND; TestPoint_THTPad_1.5x1.5mm_Drill0.7mm
TP2: +3.3V; TestPoint_Pad_2.0x2.0mm
TP3: +15V; TestPoint_Pad_2.0x2.0mm
TP4, TP5: MCU_SCL; TestPoint_Pad_1.5x1.5mm
TP6: LCD_~{RST}; TestPoint_Pad_1.5x1.5mm
TP7: LCD_SCLK; TestPoint_Pad_1.5x1.5mm
TP8: LCD_MISO; TestPoint_Pad_1.5x1.5mm
TP9: LCD_MOSI; TestPoint_Pad_1.5x1.5mm

Connections:
+3.3V: C15.2, C16.2, CN8.1, CN9.9, DSP1.30 (IM1), DSP1.31 (VDD), DSP1.33 (D7), DSP1.34 (D6), DSP1.35 (D5), DSP1.36 (D4), DSP1.37 (D3), DSP1.41 (ENABLE), DSP1.42 (READ/~WRITE), DSP1.43 (RS/DATA_~CMD), TP2.1; also elsewhere on the board
+15V: CN9.1, CN9.2, CN9.3, CN9.4, F1.2, F2.2, F3.2, F4.2, SW1.2 (B), TP3.1; also elsewhere on the board
/IO+UI/LINK1_+15V: CN2.1, CN2.7, CN2.8, F1.1
/IO+UI/LINK2_+15V: CN3.1, CN3.7, CN3.8, F2.1
/IO+UI/LINK3_+15V: CN4.1, CN4.7, CN4.8, F3.1
/IO+UI/LINK4_+15V: CN5.1, CN5.7, CN5.8, F4.1
/IO+UI/PWRIN_UNSW: CN1.1, SW1.3 (C)
BTN_DOWN: SW4.H; also elsewhere on the board
BTN_LEFT: SW4.E; also elsewhere on the board
BTN_RIGHT: SW4.K; also elsewhere on the board
BTN_SELECT: SW4.J; also elsewhere on the board
BTN_UP: SW4.G; also elsewhere on the board
ESP_~RESET: CN8.15; also elsewhere on the board
EXPSCL1: CN9.14; also elsewhere on the board
EXPSCL2: CN9.13; also elsewhere on the board
EXPSDA1: CN9.12; also elsewhere on the board
EXPSDA2: CN9.11; also elsewhere on the board
GND: C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.1, C16.1, CN1.2, CN2.2, CN2.3, CN2.6, CN2.SH, CN3.2, CN3.3, CN3.6, CN3.SH, CN4.2, CN4.3, CN4.6, CN4.SH, CN5.2, CN5.3, CN5.6, CN5.SH, CN6.A1 (GND), CN6.A12 (GND), CN6.B1 (GND), CN6.B12 (GND), CN6.S1 (SHIELD), CN7.1, CN8.4, CN8.6, CN8.8, CN8.10, CN8.12, CN8.14, CN8.16, CN8.18, CN8.20, CN9.5, CN9.6, CN9.7, CN9.8, CN9.10, DSP1.29 (IM2), DSP1.32 (VSS), Rx-1.2, Rx-2.2, SW4.A, SW4.B, SW4.C, SW4.D, SW4.F, TP1.1; also elsewhere on the board
JTAG_TCK: CN8.9; also elsewhere on the board
JTAG_TDI: CN8.5; also elsewhere on the board
JTAG_TDO: CN8.11; also elsewhere on the board
JTAG_TMS: CN8.7; also elsewhere on the board
LCD_MISO: DSP1.38 (D2/MISO/SDA2), TP8.1; also elsewhere on the board
LCD_MOSI: DSP1.39 (D1/MOSI/SDA1), TP9.1; also elsewhere on the board
LCD_SCLK: DSP1.40 (D0/SCK/SCL), TP7.1; also elsewhere on the board
LCD_~RESET: DSP1.44 (~RESET), TP6.1; also elsewhere on the board
LINK1_SCL: CN2.5; also elsewhere on the board
LINK1_SDA: CN2.4; also elsewhere on the board
LINK2_SCL: CN3.5; also elsewhere on the board
LINK2_SDA: CN3.4; also elsewhere on the board
LINK3_SCL: CN4.5; also elsewhere on the board
LINK3_SDA: CN4.4; also elsewhere on the board
LINK4_SCL: CN5.5; also elsewhere on the board
LINK4_SDA: CN5.4; also elsewhere on the board
MCU_SCL: TP4.1; also elsewhere on the board
MCU_SDA: TP5.1; also elsewhere on the board
unnamed: CN6.A5 (CC1), Rx-1.1
unnamed: CN6.B5 (CC2), Rx-2.1
unnamed: C9.1, DSP1.24 (V0)
unnamed: C10.1, DSP1.25 (V1)
unnamed: C11.1, DSP1.26 (V2)
unnamed: C12.1, DSP1.27 (V3)
unnamed: C13.1, DSP1.28 (V4)
unnamed: C14.1, DSP1.23 (VOUT)
UART_RX_I: CN7.4; also elsewhere on the board
UART_TX_O: CN7.5; also elsewhere on the board
USB_D+: CN6.A6 (D+), CN6.B6 (D+); also elsewhere on the board
USB_D-: CN6.A7 (D-), CN6.B7 (D-); also elsewhere on the board

Notes on the sheet:
Don't stuff, these are just in case the 5.1k resistors end up being required even for a self-powered device like this.

Board: 2 copper layers, 117.9 x 74.0 mm, 65 parts (41 on the bottom side), 60 nets.

## Code that names these connections

File mini-lhc-display/firmware/mini-lhc-display/src/config/default/peripheral/gpio/plib_gpio.h (part):

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// *****************************************************************************

/*** Macros for MTX_DATA6 pin ***/
#define MTX_DATA6_Set()               (LATCSET = (1<<6))
#define MTX_DATA6_Clear()             (LATCCLR = (1<<6))
#define MTX_DATA6_Toggle()            (LATCINV= (1<<6))
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#define MTX_DATA6_InputEnable()       (TRISCSET = (1<<6))
#define MTX_DATA6_Get()               ((PORTC >> 6) & 0x1)
#define MTX_DATA6_GetLatch()          ((LATC >> 6) & 0x1)
#define MTX_DATA6_PIN                  GPIO_PIN_RC6

/*** Macros for MTX_DATA7 pin ***/
#define MTX_DATA7_Set()               (LATCSET = (1<<7))
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#define MTX_nCE_A_GetLatch()          ((LATB >> 12) & 0x1)
#define MTX_nCE_A_PIN                  GPIO_PIN_RB12

/*** Macros for LED_GSCLK pin ***/
#define LED_GSCLK_Get()               ((PORTB >> 13) & 0x1)
#define LED_GSCLK_GetLatch()          ((LATB >> 13) & 0x1)
#define LED_GSCLK_PIN                  GPIO_PIN_RB13

/*** Macros for MTX_ADDR2 pin ***/
#define MTX_ADDR2_Set()               (LATASET = (1<<10))
#define MTX_ADDR2_Clear()             (LATACLR = (1<<10))
#define MTX_ADDR2_Toggle()            (LATAINV= (1<<10))
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#define MTX_ADDR2_InputEnable()       (TRISASET = (1<<10))
#define MTX_ADDR2_Get()               ((PORTA >> 10) & 0x1)
#define MTX_ADDR2_GetLatch()          ((LATA >> 10) & 0x1)
#define MTX_ADDR2_PIN                  GPIO_PIN_RA10

/*** Macros for MTX_nWR pin ***/
#define MTX_nWR_Set()               (LATASET = (1<<7))
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#define MTX_nWR_GetLatch()          ((LATA >> 7) & 0x1)
#define MTX_nWR_PIN                  GPIO_PIN_RA7

/*** Macros for LED_SPI_SCLK pin ***/
#define LED_SPI_SCLK_Set()               (LATBSET = (1<<14))
#define LED_SPI_SCLK_Clear()             (LATBCLR = (1<<14))
#define LED_SPI_SCLK_Toggle()            (LATBINV= (1<<14))
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#define LED_SPI_SCLK_InputEnable()       (TRISBSET = (1<<14))
#define LED_SPI_SCLK_Get()               ((PORTB >> 14) & 0x1)
#define LED_SPI_SCLK_GetLatch()          ((LATB >> 14) & 0x1)
#define LED_SPI_SCLK_PIN                  GPIO_PIN_RB14

/*** Macros for LCD_SPI_SCLK pin ***/
#define LCD_SPI_SCLK_Get()               ((PORTB >> 15) & 0x1)
#define LCD_SPI_SCLK_GetLatch()          ((LATB >> 15) & 0x1)
#define LCD_SPI_SCLK_PIN                  GPIO_PIN_RB15

/*** Macros for MTX_nCE_C pin ***/
#define MTX_nCE_C_Set()               (LATASET = (1<<0))
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#define MTX_nCE_D_GetLatch()          ((LATA >> 1) & 0x1)
#define MTX_nCE_D_PIN                  GPIO_PIN_RA1

/*** Macros for MTX_DATA0 pin ***/
#define MTX_DATA0_Set()               (LATCSET = (1<<0))
#define MTX_DATA0_Clear()             (LATCCLR = (1<<0))
#define MTX_DATA0_Toggle()            (LATCINV= (1<<0))
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#define MTX_DATA0_InputEnable()       (TRISCSET = (1<<0))
#define MTX_DATA0_Get()               ((PORTC >> 0) & 0x1)
#define MTX_DATA0_GetLatch()          ((LATC >> 0) & 0x1)
#define MTX_DATA0_PIN                  GPIO_PIN_RC0

/*** Macros for MTX_DATA1 pin ***/
#define MTX_DATA1_Set()               (LATCSET = (1<<1))
#define MTX_DATA1_Clear()             (LATCCLR = (1<<1))
#define MTX_DATA1_Toggle()            (LATCINV= (1<<1))
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#define MTX_DATA1_InputEnable()       (TRISCSET = (1<<1))
#define MTX_DATA1_Get()               ((PORTC >> 1) & 0x1)
#define MTX_DATA1_GetLatch()          ((LATC >> 1) & 0x1)
#define MTX_DATA1_PIN                  GPIO_PIN_RC1

/*** Macros for MTX_DATA2 pin ***/
#define MTX_DATA2_Set()               (LATCSET = (1<<2))
#define MTX_DATA2_Clear()             (LATCCLR = (1<<2))
#define MTX_DATA2_Toggle()            (LATCINV= (1<<2))
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#define MTX_DATA2_InputEnable()       (TRISCSET = (1<<2))
#define MTX_DATA2_Get()               ((PORTC >> 2) & 0x1)
#define MTX_DATA2_GetLatch()          ((LATC >> 2) & 0x1)
#define MTX_DATA2_PIN                  GPIO_PIN_RC2

/*** Macros for MTX_nFLASH pin ***/
#define MTX_nFLASH_Set()               (LATASET = (1<<2))
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#define MTX_nRD_GetLatch()          ((LATA >> 3) & 0x1)
#define MTX_nRD_PIN                  GPIO_PIN_RA3

/*** Macros for MTX_ADDR4 pin ***/
#define MTX_ADDR4_Set()               (LATASET = (1<<8))
#define MTX_ADDR4_Clear()             (LATACLR = (1<<8))
#define MTX_ADDR4_Toggle()            (LATAINV= (1<<8))
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#define MTX_ADDR4_InputEnable()       (TRISASET = (1<<8))
#define MTX_ADDR4_Get()               ((PORTA >> 8) & 0x1)
#define MTX_ADDR4_GetLatch()          ((LATA >> 8) & 0x1)
#define MTX_ADDR4_PIN                  GPIO_PIN_RA8

/*** Macros for LCD_BL_EN pin ***/
#define LCD_BL_EN_Set()               (LATBSET = (1<<4))
#define LCD_BL_EN_Clear()             (LATBCLR = (1<<4))
#define LCD_BL_EN_Toggle()            (LATBINV= (1<<4))
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#define LCD_BL_EN_InputEnable()       (TRISBSET = (1<<4))
#define LCD_BL_EN_Get()               ((PORTB >> 4) & 0x1)
#define LCD_BL_EN_GetLatch()          ((LATB >> 4) & 0x1)
#define LCD_BL_EN_PIN                  GPIO_PIN_RB4

/*** Macros for MTX_nRESET pin ***/
#define MTX_nRESET_Set()               (LATASET = (1<<4))
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#define MTX_nRESET_GetLatch()          ((LATA >> 4) & 0x1)
#define MTX_nRESET_PIN                  GPIO_PIN_RA4

/*** Macros for MTX_ADDR3 pin ***/
#define MTX_ADDR3_Set()               (LATASET = (1<<9))
#define MTX_ADDR3_Clear()             (LATACLR = (1<<9))
#define MTX_ADDR3_Toggle()            (LATAINV= (1<<9))
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#define MTX_ADDR3_InputEnable()       (TRISASET = (1<<9))
#define MTX_ADDR3_Get()               ((PORTA >> 9) & 0x1)
#define MTX_ADDR3_GetLatch()          ((LATA >> 9) & 0x1)
#define MTX_ADDR3_PIN                  GPIO_PIN_RA9

/*** Macros for MTX_DATA3 pin ***/
#define MTX_DATA3_Set()               (LATCSET = (1<<3))
#define MTX_DATA3_Clear()             (LATCCLR = (1<<3))
#define MTX_DATA3_Toggle()            (LATCINV= (1<<3))
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#define MTX_DATA3_InputEnable()       (TRISCSET = (1<<3))
#define MTX_DATA3_Get()               ((PORTC >> 3) & 0x1)
#define MTX_DATA3_GetLatch()          ((LATC >> 3) & 0x1)
#define MTX_DATA3_PIN                  GPIO_PIN_RC3

/*** Macros for MTX_DATA4 pin ***/
#define MTX_DATA4_Set()               (LATCSET = (1<<4))
#define MTX_DATA4_Clear()             (LATCCLR = (1<<4))
#define MTX_DATA4_Toggle()            (LATCINV= (1<<4))
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#define MTX_DATA4_InputEnable()       (TRISCSET = (1<<4))
#define MTX_DATA4_Get()               ((PORTC >> 4) & 0x1)
#define MTX_DATA4_GetLatch()          ((LATC >> 4) & 0x1)
#define MTX_DATA4_PIN                  GPIO_PIN_RC4

/*** Macros for MTX_DATA5 pin ***/
#define MTX_DATA5_Set()               (LATCSET = (1<<5))
#define MTX_DATA5_Clear()             (LATCCLR = (1<<5))
#define MTX_DATA5_Toggle()            (LATCINV= (1<<5))
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#define MTX_DATA5_InputEnable()       (TRISCSET = (1<<5))
#define MTX_DATA5_Get()               ((PORTC >> 5) & 0x1)
#define MTX_DATA5_GetLatch()          ((LATC >> 5) & 0x1)
#define MTX_DATA5_PIN                  GPIO_PIN_RC5

/*** Macros for LED_MCU_SDI pin ***/
#define LED_MCU_SDI_Set()               (LATBSET = (1<<5))
#define LED_MCU_SDI_Clear()             (LATBCLR = (1<<5))
#define LED_MCU_SDI_Toggle()            (LATBINV= (1<<5))
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#define LED_MCU_SDI_InputEnable()       (TRISBSET = (1<<5))
#define LED_MCU_SDI_Get()               ((PORTB >> 5) & 0x1)
#define LED_MCU_SDI_GetLatch()          ((LATB >> 5) & 0x1)
#define LED_MCU_SDI_PIN                  GPIO_PIN_RB5

/*** Macros for LED_MCU_SDO pin ***/
#define LED_MCU_SDO_Set()               (LATBSET = (1<<6))
#define LED_MCU_SDO_Clear()             (LATBCLR = (1<<6))
#define LED_MCU_SDO_Toggle()            (LATBINV= (1<<6))
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#define LED_MCU_SDO_InputEnable()       (TRISBSET = (1<<6))
#define LED_MCU_SDO_Get()               ((PORTB >> 6) & 0x1)
#define LED_MCU_SDO_GetLatch()          ((LATB >> 6) & 0x1)
#define LED_MCU_SDO_PIN                  GPIO_PIN_RB6

/*** Macros for LED_LAT pin ***/
#define LED_LAT_Set()               (LATBSET = (1<<7))
#define LED_LAT_Clear()             (LATBCLR = (1<<7))
#define LED_LAT_Toggle()            (LATBINV= (1<<7))
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#define LED_LAT_InputEnable()       (TRISBSET = (1<<7))
#define LED_LAT_Get()               ((PORTB >> 7) & 0x1)
#define LED_LAT_GetLatch()          ((LATB >> 7) & 0x1)
#define LED_LAT_PIN                  GPIO_PIN_RB7

// *****************************************************************************
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
File cern-display-controller/firmware/cern-display-controller/pins.h:

#define PIN_LED_STATUS 2
#define PIN_LED_WIFI   3

#define PIN_SDA 11
#define PIN_SCL 10

#define PIN_UART_TX 16
#define PIN_UART_RX 17

#define PIN_BTN_UP     19
#define PIN_BTN_DOWN   20
#define PIN_BTN_LEFT   21
#define PIN_BTN_RIGHT  22
#define PIN_BTN_SELECT 23

#define PIN_LCD_MOSI   18
#define PIN_LCD_MISO   15
#define PIN_LCD_SCK    0
#define PIN_LCD_nRESET 1

## Commit log

2025-05-03 Initial commit of completed controller schematic
    Still finishing a couple footprints, then can move on to PCB.
2025-05-03 Schematic inc. footprinting is complete
    Swapped out the main regulator for a different model as well, original one had a very complicated footprint and I didn't need the small size of it for this project anyways, so just switched to a simp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
2025-05-03 Added fuse to regulator input
    Datasheet says an input fuse is required, so added that.
2025-05-04 Basic board placement/routing is complete
    Still need to fine-tune routing and placement, do silk, etc.
2025-05-04 All DRC errors cleared up
2025-05-04 All DRC warnings cleared up
    Next: finalizing silkscreen
2025-05-10 Completed PCB layout
    PCB layout is complete and checklisted. Need to do the 24h pause and re-check still.
2025-05-10 Started schematic capture for mini LHC display
    Alphanumeric accelerator/beam status displays laid out, as well as general power and MCU and such. Next up, TLC5955s and the t(SB) and energy displays.
2025-05-16 Completed LED placement and connections
    Next: Footprint assignment, and consider adding a small LCD
2025-05-17 Completed integrating LCD into schematic
    Next: footprint assignment
2025-05-17 Footprints all created and assigned
    Next: Run through schematic checklist
2025-05-18 Added test points, completed schematic checklist
    Next: PCB layout!
2025-05-18 Switched display size from L to M
    Once I looked at the PCB the L was too big, M is same resolution but in a smaller package
2025-05-19 Switched away from PTH ISRs
    Now using AP62300T switching regulators and their support components. All SMD, cheaper, and supports much higher power.
2025-05-19 Switched link connector to SMD
    Found a fully-SMD no-holes shielded connector, so going to use that instead to keep the top clean looking.
2025-05-25 PCB layout in progress
    Major components laid out, as are both regulators. LED rings are roughly laid out but need some aesthetic tweaking. Moving MCU and support components into place is next.
2025-05-30 Routing continues
    Mostly-complete: matrix displays, 7-segment displays, +15V around the ring
    In-progress: Misc. LEDs
    Next: Completion of ring
2025-09-01 Routing of misc. LEDs complete
2025-09-01 Routed 37 ring LEDs, 11 to go
2025-09-02 All beam LEDs routed
    I think that's the last of the displays, now all the logic and interface circuitry to route.
2025-09-02 Logic routing in progress, 100 unrouteds left
2025-09-06 Dot matrix buffer error fixed
    Data buffer direction pin was connected to a display enable signal, should have been connected to ~RD. Fixed.
2025-09-09 Routing in progress, 80 unrouteds left
2025-09-09 Routing continues, 60 unrouteds left
2025-09-10 Routing continues, 50 unrouteds left
2025-09-10 Routing continues, 25 unrouteds left
2025-09-10 Routing continues, 10 unrouteds left
2025-09-10 Routing complete!
    Next step: routing cleanup and DRC fixes.
2025-09-12 DRC and general cleanup complete
    Checklist running is next
2025-09-14 Board constraints now set up for intended board house
    DRC fixes all implemented for this house, all passing now.
2025-09-14 Started running through PCB checklist
    Still have to do from silkscreen items down.
2025-09-15 Completed PCB checklist!
    Now in the 24h waiting period before sending boards off to get made.
2025-09-16 CAM complete/checked for the controller board
2025-09-16 A few silkscreen tweaks during the 24h re-check
    Upside down text on the GSCLK test point, and missing label on SW1/Reset.
2025-09-16 CAM for display board complete and checked
2025-09-16 Adding CAM ZIPs to gitignore
2025-10-23 Fixing value for R3
    Was correct (27k) on BOM, but wrong on schematic.
2026-02-27 Adding current version of display controller firmware
    Could use cleanup and some finishing, but is working and in daily use now.
2026-02-27 Adding current version of display board firmware
    Lots of cleanup and bug fixes still to do, but it's in daily use now and works well.
